# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: q1_main.c OutStr.s DELAY150.s.asm keyGet.c keyMatrix.c timer.c gpio_and_adc.c
    ./LCD/: delay.s init.s lcd_number.s lcd_send_data.s lcd_update_screen.s screen.s
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
